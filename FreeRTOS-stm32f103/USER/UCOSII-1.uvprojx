# Keil uVision project UCOSII-1.uvprojx, settings and files
target UCOSII-1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreeRTOS_STM32F103 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\OS\include;..\OS\stm32f103\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c uart.c rfifo.c wdg.c led.c keydetect.c usmart.c usmart_config.c usmart_str.c longsung.c mqtt_msg.c xlist.c
    ../OS/stm32f103/: timer.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group OS
    ../OS/: croutine.c event_groups.c heap_1.c list.c queue.c tasks.c timers.c
    ../OS/stm32f103/: port.c xmalloc.c
