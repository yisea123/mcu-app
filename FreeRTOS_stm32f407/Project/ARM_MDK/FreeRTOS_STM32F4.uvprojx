# Keil uVision project FreeRTOS_STM32F4.uvprojx, settings and files
target FreeRTOS_STM32F4 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_STM32F4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries;..\..\Libraries\CORE;..\..\Libraries\FWLIB\inc;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\FreeRTOS;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\BSP;..\..\USER;..\..\USMART;..\..\FATFS\src;..\..\FATFS\exfuns;..\..\Helix\pub;..\..\Helix\real;..\..\AMR1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Libraries/CORE/: core_cm4.h core_cmSimd.h
    ../../Libraries/StartUp/: startup_stm32f40_41xxx.s
    ../../Libraries/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../../Libraries/FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_rng.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_sdio.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
  group USER
    ../../USER/: main.c rfifo.c wavplay.c audioplay.c
  group FreeRTOS
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group USMART
    ../../USMART/: usmart.c usmart_config.c usmart_str.c
  group BSP
    ../../BSP/: led.c rtc.c exti.c key.c rng.c iwdg.c adc.c dma.c stmflash.c spi.c w25qxx.c sdio_sdcard.c wm8978.c i2s.c miic.c
  group FATFS
    ../../FATFS/src/: diskio.c ff.c
    ../../FATFS/exfuns/: fattester.c exfuns.c
    ../../FATFS/src/option/: syscall.c cc936.c
  group Helix
    ../../Helix/: mp3tabs.c mp3dec.c mp3_play.c
    ../../Helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../Helix/real/arm/: asmmisc.S asmpoly_thumb2.S
  group AMR
    ../../AMR1/: agc.c b_cn_cod.c basicop2.c bgnscd.c bits2prm.c c_g_aver.c copy.c count.c d_homing.c d_plsf_3.c d_plsf.c d_plsf_5.c d2_11pf.c d3_14pf.c d4_17pf.c d8_31pf.c d1035pf.c dec_amr.c dec_lag3.c dec_lag6.c ec_gains.c dtx_dec.c gc_pred.c gmed_n.c int_lpc.c lsp_avg.c lsp_az.c lsp_lsf.c oper_32b.c n_proc.c ph_disp.c post_pro.c pred_lt.c pstfilt.c reorder.c set_zero.c sqrt_l.c strfunc.c syn_filt.c inv_sqrt.c d_gain_c.c ex_ctrl.c dec_gain.c a_refl.c d_gain_p.c d2_9pf.c weight_a.c residu.c preemph.c pow2.c log2.c int_lsf.c amrplay.c sp_dec.c
