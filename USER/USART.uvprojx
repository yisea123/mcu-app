# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: USART +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=Y:\mirror\mcu\rom\Bin\USART.bin Y:\mirror\mcu\rom\OBJ\USART.axf
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\MALLOC;..\KFIFO;..\PROTOCOL;..\HARDWARE\CAN;..\USMART;..\HARDWARE\RTC;..\LIST;..\TEST;..\HARDWARE\DMA;..\HARDWARE\IOCTR;..\HARDWARE\STMFLASH;..\HARDWARE\IWDG;..\HARDWARE\RNG
  memory RVCT4: ROM 0x8000000 size 0xd0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c pending.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/IOCTR/: ioctr.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IWDG/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_iwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group KFIFO
    ../KFIFO/: kfifo.c
  group PROTOCOL
    ../PROTOCOL/: uart_command.c car_event.c tmodem.c bootloader_update.c rsa.c md5.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LIST
    ../LIST/: list.c
  group TEST
    ../TEST/: test.c
